# Keil uVision project GD32_KB.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GD32_KB
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: .\USER\include;.\CMSIS\GD\GD32F10x\Include;.\GD32F10x_standard_peripheral\Include;.\usbd\Include;.\device\Include;.\hid\Include;.\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
    ./CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group USER
    ./USER/source/: gd32f10x_it.c gd32f10x_usbd_hw.c hid_keyboard_itf.c key.c
    ./USER/: main.c
  group usbd
    ./usbd/Source/: usbd_lld_core.c usbd_lld_int.c
    ./device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group hid
    ./hid/Source/: standard_hid_core.c
  group GD32F10x_standard_peripheral
    ./GD32F10x_standard_peripheral/Source/: gd32f10x_dma.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c
